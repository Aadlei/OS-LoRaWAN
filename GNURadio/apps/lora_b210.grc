options:
  parameters:
    author: Ådne Sigurd Leirdal & Gustav Halvorsen
    generate_options: qt_gui
    id: lora_b210
    output_language: python
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868100000.0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '12'
  states: {}
- name: sink_freq2
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: sink_sf2
  id: variable
  parameters:
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-300000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    minoutbuf: '65568'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    minoutbuf: '65568'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    minoutbuf: '65568'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '10'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_crc_verif_0_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_crc_verif_0_0_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_crc_verif_0_0_1
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_crc_verif_0_1
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_0_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_0_0_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_0_1
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_deinterleaver_0_1
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0_1
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_1
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_0_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_0_0_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_0_1
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_fft_demod_0_1
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: '868000000'
    impl_head: impl_head
    os_factor: '16'
    preamb_len: '8'
    sf: '12'
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: '868000000'
    impl_head: impl_head
    os_factor: '16'
    preamb_len: '8'
    sf: '12'
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: '868000000'
    impl_head: impl_head
    os_factor: '16'
    preamb_len: '8'
    sf: '7'
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_0_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: '868000000'
    impl_head: impl_head
    os_factor: '16'
    preamb_len: '8'
    sf: '12'
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_0_1
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: '868000000'
    impl_head: impl_head
    os_factor: '16'
    preamb_len: '8'
    sf: '7'
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_1
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: '868000000'
    impl_head: impl_head
    os_factor: '16'
    preamb_len: '8'
    sf: '7'
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sink_sf2
  states: {}
- name: lora_sdr_gray_demap_0_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_0_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_0_0_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_0_1
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_gray_mapping_0_1
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_0_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_0_0_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_0_1
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0_1
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sink_sf2
  states: {}
- name: lora_sdr_hamming_enc_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: 'False'
    impl_head: 'False'
  states: {}
- name: lora_sdr_header_0_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: 'False'
    impl_head: 'False'
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: impl_head
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_header_decoder_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: impl_head
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_header_decoder_0_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: impl_head
    ldro: '2'
    pay_len: '255'
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_0_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: impl_head
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_header_decoder_0_0_1
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: impl_head
    ldro: '2'
    pay_len: '255'
    print_header: 'False'
  states: {}
- name: lora_sdr_header_decoder_0_1
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: impl_head
    ldro: '2'
    pay_len: '255'
    print_header: 'False'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: bw
    cr: cr
    ldro: '2'
    sf: sink_sf2
  states: {}
- name: lora_sdr_interleaver_0_0
  id: lora_sdr_interleaver
  parameters:
    bw: bw
    cr: cr
    ldro: '2'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sink_sf2*samp_rate/bw)
    preamb_len: '8'
    samp_rate: '2000000'
    sf: sink_sf2
    sync_words: '0x34'
  states: {}
- name: lora_sdr_modulate_0_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    preamb_len: '8'
    samp_rate: '2000000'
    sf: sf
    sync_words: '0x34'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: file_source
    use_length_tag: 'False'
  states: {}
- name: lora_sdr_whitening_0_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: file_source
    use_length_tag: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '77500'
    decim: '1'
    gain: '1'
    minoutbuf: '65568'
    samp_rate: '1000000'
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '77500'
    decim: '1'
    gain: '1'
    minoutbuf: '65568'
    samp_rate: '1000000'
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '77500'
    decim: '1'
    gain: '1'
    minoutbuf: '65568'
    samp_rate: '1000000'
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    bw0: bw
    freq0: sink_freq2
    gain0: '10'
    if_gain0: '20'
    sample_rate: '2000000'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_sink_0_0_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    bw0: bw
    freq0: sink_freq2
    gain0: '10'
    if_gain0: '20'
    sample_rate: '2000000'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_sink_0_0_1
  id: osmosdr_sink
  parameters:
    args: bladerf=0,nchan=2
    bb_gain0: '20'
    bb_gain1: '20'
    bw0: bw
    bw1: sink_freq2
    corr1: '0'
    freq0: sink_freq2
    freq1: sink_freq2
    gain0: '10'
    gain1: '10'
    if_gain0: '20'
    if_gain1: '20'
    nchan: '2'
    sample_rate: '2000000'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    bw0: '2000000'
    freq0: '868000000'
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: '2000000'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '2000000'
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '2000000'
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 125e3
    center_freq0: center_freq
    gain0: '10'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 125e3
    center_freq0: center_freq
    gain0: '10'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: bandwidth
    center_freq0: center_freq
    gain0: '10'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8089'
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pull_source_0_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5554
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5561
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_0_1
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5560
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_1
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5559
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_conjugate_cc_0, '0', osmosdr_sink_0_0, '0']
- [blocks_conjugate_cc_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_conjugate_cc_0_0, '0', osmosdr_sink_0_0_0, '0']
- [blocks_conjugate_cc_0_0, '0', osmosdr_sink_0_0_1, '1']
- [blocks_conjugate_cc_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_moving_average_xx_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [lora_sdr_crc_verif_0, '0', zeromq_push_sink_0, '0']
- [lora_sdr_crc_verif_0_0, '0', zeromq_push_sink_0_0, '0']
- [lora_sdr_crc_verif_0_0_0, '0', zeromq_push_sink_0_0_0, '0']
- [lora_sdr_crc_verif_0_0_0_0, '0', zeromq_push_sink_0_0_0_0, '0']
- [lora_sdr_crc_verif_0_0_1, '0', zeromq_push_sink_0_0_1, '0']
- [lora_sdr_crc_verif_0_1, '0', zeromq_push_sink_0_1, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_deinterleaver_0_0, '0', lora_sdr_hamming_dec_0_0, '0']
- [lora_sdr_deinterleaver_0_0_0, '0', lora_sdr_hamming_dec_0_0_0, '0']
- [lora_sdr_deinterleaver_0_0_0_0, '0', lora_sdr_hamming_dec_0_0_0_0, '0']
- [lora_sdr_deinterleaver_0_0_1, '0', lora_sdr_hamming_dec_0_0_1, '0']
- [lora_sdr_deinterleaver_0_1, '0', lora_sdr_hamming_dec_0_1, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_dewhitening_0_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_dewhitening_0_0_0, '0', lora_sdr_crc_verif_0_0_0, '0']
- [lora_sdr_dewhitening_0_0_0_0, '0', lora_sdr_crc_verif_0_0_0_0, '0']
- [lora_sdr_dewhitening_0_0_1, '0', lora_sdr_crc_verif_0_0_1, '0']
- [lora_sdr_dewhitening_0_1, '0', lora_sdr_crc_verif_0_1, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_fft_demod_0_0, '0', lora_sdr_gray_mapping_0_0, '0']
- [lora_sdr_fft_demod_0_0_0, '0', lora_sdr_gray_mapping_0_0_0, '0']
- [lora_sdr_fft_demod_0_0_0_0, '0', lora_sdr_gray_mapping_0_0_0_0, '0']
- [lora_sdr_fft_demod_0_0_1, '0', lora_sdr_gray_mapping_0_0_1, '0']
- [lora_sdr_fft_demod_0_1, '0', lora_sdr_gray_mapping_0_1, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0_0, '0', lora_sdr_fft_demod_0_0, '0']
- [lora_sdr_frame_sync_0_0_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [lora_sdr_frame_sync_0_0_0, '0', lora_sdr_fft_demod_0_0_0, '0']
- [lora_sdr_frame_sync_0_0_0_0, '0', lora_sdr_fft_demod_0_0_0_0, '0']
- [lora_sdr_frame_sync_0_0_1, '0', lora_sdr_fft_demod_0_0_1, '0']
- [lora_sdr_frame_sync_0_1, '0', lora_sdr_fft_demod_0_1, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_demap_0_0, '0', lora_sdr_modulate_0_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_gray_mapping_0_0, '0', lora_sdr_deinterleaver_0_0, '0']
- [lora_sdr_gray_mapping_0_0_0, '0', lora_sdr_deinterleaver_0_0_0, '0']
- [lora_sdr_gray_mapping_0_0_0_0, '0', lora_sdr_deinterleaver_0_0_0_0, '0']
- [lora_sdr_gray_mapping_0_0_1, '0', lora_sdr_deinterleaver_0_0_1, '0']
- [lora_sdr_gray_mapping_0_1, '0', lora_sdr_deinterleaver_0_1, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_dec_0_0, '0', lora_sdr_header_decoder_0_0, '0']
- [lora_sdr_hamming_dec_0_0_0, '0', lora_sdr_header_decoder_0_0_0, '0']
- [lora_sdr_hamming_dec_0_0_0_0, '0', lora_sdr_header_decoder_0_0_0_0, '0']
- [lora_sdr_hamming_dec_0_0_1, '0', lora_sdr_header_decoder_0_0_1, '0']
- [lora_sdr_hamming_dec_0_1, '0', lora_sdr_header_decoder_0_1, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_hamming_enc_0_0, '0', lora_sdr_interleaver_0_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_header_0_0, '0', lora_sdr_hamming_enc_0_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_header_decoder_0_0, '0', lora_sdr_dewhitening_0_0, '0']
- [lora_sdr_header_decoder_0_0, frame_info, lora_sdr_frame_sync_0_0, frame_info]
- [lora_sdr_header_decoder_0_0_0, '0', lora_sdr_dewhitening_0_0_0, '0']
- [lora_sdr_header_decoder_0_0_0, frame_info, lora_sdr_frame_sync_0_0_0, frame_info]
- [lora_sdr_header_decoder_0_0_0_0, '0', lora_sdr_dewhitening_0_0_0_0, '0']
- [lora_sdr_header_decoder_0_0_0_0, frame_info, lora_sdr_frame_sync_0_0_0_0, frame_info]
- [lora_sdr_header_decoder_0_0_1, '0', lora_sdr_dewhitening_0_0_1, '0']
- [lora_sdr_header_decoder_0_0_1, frame_info, lora_sdr_frame_sync_0_0_1, frame_info]
- [lora_sdr_header_decoder_0_1, '0', lora_sdr_dewhitening_0_1, '0']
- [lora_sdr_header_decoder_0_1, frame_info, lora_sdr_frame_sync_0_1, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_interleaver_0_0, '0', lora_sdr_gray_demap_0_0, '0']
- [lora_sdr_modulate_0, '0', blocks_conjugate_cc_0, '0']
- [lora_sdr_modulate_0_0, '0', blocks_conjugate_cc_0_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [lora_sdr_whitening_0_0, '0', lora_sdr_header_0_0, '0']
- [low_pass_filter_0, '0', lora_sdr_frame_sync_0, '0']
- [low_pass_filter_0, '0', lora_sdr_frame_sync_0_1, '0']
- [low_pass_filter_0_0, '0', lora_sdr_frame_sync_0_0, '0']
- [low_pass_filter_0_0, '0', lora_sdr_frame_sync_0_0_1, '0']
- [low_pass_filter_0_0_0, '0', lora_sdr_frame_sync_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', lora_sdr_frame_sync_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '1']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0, '1']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0_0, '1']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_pull_source_0, '0', lora_sdr_whitening_0, '0']
- [zeromq_pull_source_0_0, '0', lora_sdr_whitening_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
