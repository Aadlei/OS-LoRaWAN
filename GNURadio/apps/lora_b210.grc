options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 8681e5
  states: {}
- name: gain
  id: variable
  parameters:
    value: '120'
  states: {}
- name: low_pass_samp_rate
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2e6 '
  states: {}
- name: sf
  id: variable
  parameters:
    value: '12'
  states: {}
- name: sf2
  id: variable
  parameters:
    value: '7'
  states: {}
- name: sink_freq
  id: variable
  parameters:
    value: 8681e5
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-300000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_0_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_1
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_1_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_crc_verif_0_2
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_deinterleaver_0_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_deinterleaver_0_0_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_deinterleaver_0_1
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_deinterleaver_0_1_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_deinterleaver_0_2
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_1
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_1_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_2
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_fft_demod_0_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_fft_demod_0_0_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_fft_demod_0_1
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_fft_demod_0_1_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_fft_demod_0_2
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: int(868e6)
    impl_head: 'False'
    os_factor: '16'
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: int(868e6)
    impl_head: 'False'
    os_factor: '16'
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: int(868e6)
    impl_head: 'False'
    os_factor: '16'
    preamb_len: '8'
    sf: sf2
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_1
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: int(868e6)
    impl_head: 'False'
    os_factor: '16'
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_1_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: int(868e6)
    impl_head: 'False'
    os_factor: '16'
    preamb_len: '8'
    sf: sf2
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_frame_sync_0_2
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '125000'
    center_freq: int(868e6)
    impl_head: 'False'
    os_factor: '16'
    preamb_len: '8'
    sf: sf2
    show_log_port: 'False'
    sync_word: '0x34'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_demap_0_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf2
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_gray_mapping_0_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_gray_mapping_0_0_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_gray_mapping_0_1
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_gray_mapping_0_1_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_gray_mapping_0_2
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0_0_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0_1
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0_1_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0_2
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: '1'
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: '1'
    sf: sf2
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: '1'
    has_crc: 'False'
    impl_head: 'False'
  states: {}
- name: lora_sdr_header_0_0
  id: lora_sdr_header
  parameters:
    cr: '1'
    has_crc: 'False'
    impl_head: 'False'
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_header_decoder_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_header_decoder_0_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_header_decoder_0_1
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_header_decoder_0_1_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_header_decoder_0_2
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: '1'
    ldro: '2'
    sf: sf
  states: {}
- name: lora_sdr_interleaver_0_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: '1'
    ldro: '2'
    sf: sf2
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: int(bandwidth)
    frame_zero_padd: int(20*2**sf*samp_rate/bandwidth)
    preamb_len: '8'
    samp_rate: int(samp_rate)
    sf: sf
    sync_words: '0x34'
  states: {}
- name: lora_sdr_modulate_0_0
  id: lora_sdr_modulate
  parameters:
    bw: int(bandwidth)
    frame_zero_padd: int(20*2**sf*samp_rate/bandwidth)
    preamb_len: '8'
    samp_rate: int(samp_rate)
    sf: sf2
    sync_words: '0x34'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: file_source
    use_length_tag: 'False'
  states: {}
- name: lora_sdr_whitening_0_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: file_source
    use_length_tag: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '77500'
    decim: '1'
    gain: '1'
    minoutbuf: '65568'
    samp_rate: low_pass_samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '77500'
    decim: '1'
    gain: '1'
    minoutbuf: '65568'
    samp_rate: low_pass_samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '77500'
    decim: '1'
    gain: '1'
    minoutbuf: '65568'
    samp_rate: low_pass_samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bandwidth
    center_freq0: sink_freq
    dev_args: master_clock_rate=30.72e6
    gain0: gain
    samp_rate: 2e6
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bandwidth
    center_freq0: sink_freq
    dev_args: master_clock_rate=30.72e6
    gain0: gain
    samp_rate: 2e6
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 125e3
    center_freq0: 868e6
    gain0: gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_sink_freq
    port: '8089'
    variable: sink_freq
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8089'
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5554
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pull_source_0_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5560
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_1
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_1_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5561
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0_2
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5559
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [blocks_conjugate_cc_0, '0', uhd_usrp_sink_0, '0']
- [blocks_conjugate_cc_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_1, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_0, '0']
- [lora_sdr_crc_verif_0, '0', zeromq_push_sink_0, '0']
- [lora_sdr_crc_verif_0_0, '0', zeromq_push_sink_0_0, '0']
- [lora_sdr_crc_verif_0_0_0, '0', zeromq_push_sink_0_0_0, '0']
- [lora_sdr_crc_verif_0_1, '0', zeromq_push_sink_0_1, '0']
- [lora_sdr_crc_verif_0_1_0, '0', zeromq_push_sink_0_1_0, '0']
- [lora_sdr_crc_verif_0_2, '0', zeromq_push_sink_0_2, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_deinterleaver_0_0, '0', lora_sdr_hamming_dec_0_0, '0']
- [lora_sdr_deinterleaver_0_0_0, '0', lora_sdr_hamming_dec_0_0_0, '0']
- [lora_sdr_deinterleaver_0_1, '0', lora_sdr_hamming_dec_0_1, '0']
- [lora_sdr_deinterleaver_0_1_0, '0', lora_sdr_hamming_dec_0_1_0, '0']
- [lora_sdr_deinterleaver_0_2, '0', lora_sdr_hamming_dec_0_2, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_dewhitening_0_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_dewhitening_0_0_0, '0', lora_sdr_crc_verif_0_0_0, '0']
- [lora_sdr_dewhitening_0_1, '0', lora_sdr_crc_verif_0_1, '0']
- [lora_sdr_dewhitening_0_1_0, '0', lora_sdr_crc_verif_0_1_0, '0']
- [lora_sdr_dewhitening_0_2, '0', lora_sdr_crc_verif_0_2, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_fft_demod_0_0, '0', lora_sdr_gray_mapping_0_0, '0']
- [lora_sdr_fft_demod_0_0_0, '0', lora_sdr_gray_mapping_0_0_0, '0']
- [lora_sdr_fft_demod_0_1, '0', lora_sdr_gray_mapping_0_1, '0']
- [lora_sdr_fft_demod_0_1_0, '0', lora_sdr_gray_mapping_0_1_0, '0']
- [lora_sdr_fft_demod_0_2, '0', lora_sdr_gray_mapping_0_2, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0_0, '0', lora_sdr_fft_demod_0_0, '0']
- [lora_sdr_frame_sync_0_0_0, '0', lora_sdr_fft_demod_0_0_0, '0']
- [lora_sdr_frame_sync_0_1, '0', lora_sdr_fft_demod_0_1, '0']
- [lora_sdr_frame_sync_0_1_0, '0', lora_sdr_fft_demod_0_1_0, '0']
- [lora_sdr_frame_sync_0_2, '0', lora_sdr_fft_demod_0_2, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_demap_0_0, '0', lora_sdr_modulate_0_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_gray_mapping_0_0, '0', lora_sdr_deinterleaver_0_0, '0']
- [lora_sdr_gray_mapping_0_0_0, '0', lora_sdr_deinterleaver_0_0_0, '0']
- [lora_sdr_gray_mapping_0_1, '0', lora_sdr_deinterleaver_0_1, '0']
- [lora_sdr_gray_mapping_0_1_0, '0', lora_sdr_deinterleaver_0_1_0, '0']
- [lora_sdr_gray_mapping_0_2, '0', lora_sdr_deinterleaver_0_2, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_dec_0_0, '0', lora_sdr_header_decoder_0_0, '0']
- [lora_sdr_hamming_dec_0_0_0, '0', lora_sdr_header_decoder_0_0_0, '0']
- [lora_sdr_hamming_dec_0_1, '0', lora_sdr_header_decoder_0_1, '0']
- [lora_sdr_hamming_dec_0_1_0, '0', lora_sdr_header_decoder_0_1_0, '0']
- [lora_sdr_hamming_dec_0_2, '0', lora_sdr_header_decoder_0_2, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_hamming_enc_0_0, '0', lora_sdr_interleaver_0_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_header_0_0, '0', lora_sdr_hamming_enc_0_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_header_decoder_0_0, '0', lora_sdr_dewhitening_0_0, '0']
- [lora_sdr_header_decoder_0_0, frame_info, lora_sdr_frame_sync_0_0, frame_info]
- [lora_sdr_header_decoder_0_0_0, '0', lora_sdr_dewhitening_0_0_0, '0']
- [lora_sdr_header_decoder_0_0_0, frame_info, lora_sdr_frame_sync_0_0_0, frame_info]
- [lora_sdr_header_decoder_0_1, '0', lora_sdr_dewhitening_0_1, '0']
- [lora_sdr_header_decoder_0_1, frame_info, lora_sdr_frame_sync_0_1, frame_info]
- [lora_sdr_header_decoder_0_1_0, '0', lora_sdr_dewhitening_0_1_0, '0']
- [lora_sdr_header_decoder_0_1_0, frame_info, lora_sdr_frame_sync_0_1_0, frame_info]
- [lora_sdr_header_decoder_0_2, '0', lora_sdr_dewhitening_0_2, '0']
- [lora_sdr_header_decoder_0_2, frame_info, lora_sdr_frame_sync_0_2, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_interleaver_0_0, '0', lora_sdr_gray_demap_0_0, '0']
- [lora_sdr_modulate_0, '0', blocks_conjugate_cc_0, '0']
- [lora_sdr_modulate_0_0, '0', blocks_conjugate_cc_0_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [lora_sdr_whitening_0_0, '0', lora_sdr_header_0_0, '0']
- [low_pass_filter_0, '0', lora_sdr_frame_sync_0, '0']
- [low_pass_filter_0, '0', lora_sdr_frame_sync_0_2, '0']
- [low_pass_filter_0_0, '0', lora_sdr_frame_sync_0_1, '0']
- [low_pass_filter_0_0, '0', lora_sdr_frame_sync_0_1_0, '0']
- [low_pass_filter_0_1, '0', lora_sdr_frame_sync_0_0, '0']
- [low_pass_filter_0_1, '0', lora_sdr_frame_sync_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_pull_source_0, '0', lora_sdr_whitening_0, '0']
- [zeromq_pull_source_0_0, '0', lora_sdr_whitening_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
